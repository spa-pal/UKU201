# Keil uVision project 1.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103RC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000BFFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: 1
  c flags: Optim=1
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group Startup
    ./: STM32F10x.s STM32_Init.c
  group Sources
    ./: main.c 25lc640.c eeprom_map.c memo.c gran.c control.c mess.c mcp2515.c avar_hndl.c beep.c
  group Connect
    ./: uart1.c uart2.c modbus.c full_can.c
